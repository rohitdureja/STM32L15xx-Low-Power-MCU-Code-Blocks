# Keil uVision project LCD_Temperature.uvproj, settings and files
target STM32L_Template (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Template +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Libraries\STM32L1xx_StdPeriph_Driver\inc;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Libraries\CMSIS\Include;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Libraries\CMSIS\Device\ST\STM32L1xx\Include;C:\STMicroelectronics\STM32L1_Discovery_Firmware_Pack_V1.0.3\Utilities\STM32L-DISCOVERY;..\STM32L_Template
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group User
    ./: main.c stm32l1xx_it.c
  group Peripheral-Library
    C:/st/stsw-stm32077/STM32L1xx_StdPeriph_Lib_V1.3.0/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ./: system_stm32l1xx.c
  group MDK-ARM
    C:/STMicroelectronics/STM32L1_Discovery_Firmware_Pack_V1.0.3/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
